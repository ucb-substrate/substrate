* Generated by Spectre plugin for Substrate

simulator lang=spectre

{% for line in spectre_directives -%}
{{ line }}
{% endfor %}

simulator lang=spice
{% for line in spice_directives -%}
{{ line }}
{% endfor %}

* Include libraries
{% for lib in libs -%}
.lib {{ lib.path }} {{ lib.section }}
{% endfor %}
* Includes
{% for include in includes -%}
.include {{ include }}
{% endfor %}

* Analyses
{% for analysis in analyses -%}
{{ analysis }}
{% endfor %}
.end
