* vdivider
* Schematic generated by Substrate
.subckt vdivider out vdd vss
XR1 vdd out resistor_2K
XR2 out vss resistor_1K
.ends vdivider
.subckt resistor_2K p n
R1 p n 2K
.ends resistor_2K
.subckt resistor_1K p n
R1 p n 1K
.ends resistor_1K

.subckt vdivider_tb vss
Vdd vdd vss dc 1.8 ac 1
Xdut out vdd vss vdivider
.ends

Xdut 0 vdivider_tb
